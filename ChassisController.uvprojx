# Keil uVision project ChassisController.uvprojx, settings and files
target ChassisController (6230000::V6.23::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ChassisController
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=4
  c include: .\Src;.\Src\Peripherals;.\Src\Devices;.\Src\MiddleWare;.\Src\Algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source
    ./Src/: motion_control.c ros_interface.c
  group Algorithm
    ./Src/Algorithm/: crc32.c pid.c kalman_filter.c
  group Drivers
    ./Src/Devices/: battery.c dc_motor.c w25qxx.c rc_receiver.c rc_receiver_ht8a.c rc_receiver_wfly.c
  group Peripherals
    ./Src/Peripherals/: flash.c spi.c timer.c usart.c
  group Protocol
    ./Src/Protocol/: s_bus.c
  group :CubeMX:CubeMX
    ./STM32CubeMX/ChassisController/STM32CubeMX/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c stm32f4xx_hal_timebase_tim.c
    ./STM32CubeMX/ChassisController/STM32CubeMX/MDK-ARM/: startup_stm32f407xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/ChassisController/STM32CubeMX/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_uart.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c stm32f4xx_ll_exti.c stm32f4xx_hal_spi.c
  group MiddleWare
    ./Src/MiddleWare/: udp.c
software components: CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, CMSIS Driver:Ethernet MAC 3.1.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:CubeMX 1.0.0, Network:CORE 8.1.0, Network:Interface:ETH 8.1.0, Network:Socket:TCP 8.1.0, Network:Socket:UDP 8.1.0
